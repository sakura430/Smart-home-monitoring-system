# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\STM32Core;.\Lib;.\FreeRTOS;.\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32Core
    ./STM32Core/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Lib
    ./Lib/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group FreeRTOS
    ./FreeRTOS/: atomic.h croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h FreeRTOSConfig.h heap_4.c list.c list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.c stream_buffer.h task.h tasks.c timers.c timers.h
  group Utils
    ./Utils/: USART1.c USART1.h USART2.c USART2.h USART3.c USART3.h GPIO.h GPIO.c wifi_connect.c wifi_connect.h tcp_connect.c tcp_connect.h esp01s_switch.c esp01s_switch.h tcp_send_data.c tcp_send_data.h Delay.c Delay.h OLED.c OLED.h OLED_Font.h buzzer.c buzzer.h LED.c LED.h ADC.c ADC.h flash.c flash.h spi.c spi.h IWDG.c IWDG.h RTC.c RTC.h Key.c Key.h
  group User
    ./Utils/: header.h
    ./User/: main.c
